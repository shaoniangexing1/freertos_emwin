# Keil uVision project LCD_Hardware.uvprojx, settings and files
target LCD_Hardware (6240000::V6.24::ARMCLANG)
  device: STM32H562VITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: LCD_Hardware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H562xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;./Inf;./BSP;./Middel/freertos;./Middel/freertos/include;./Middel/freertos/portable;./App;./Middel/emwin/Config;./Middel/emwin/Inc;./Middel/emwin/Lib/ARM;./Middel/emwin/OS;./Middel/emwin/GUI_NEW_Block;./Com
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h562xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c flash.c iwdg.c spi.c tim.c usart.c stm32h5xx_it.c stm32h5xx_hal_msp.c stm32h5xx_hal_timebase_tim.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group App
    ./App/: app.c
  group Inf
    ./Inf/: Inf_ST7785_LCD.c Inf_ST7789_LCD.c Inf_FT6236.c
  group BSP
    ./BSP/: I2C.c BSP_ST7785_SPI.c
  group Mid/FreeRtos
    ./Middel/freertos/: FreeRTOSConfig.h croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middel/freertos/portable/: heap_4.c port.c portasm.c
  group Mid/emwin/config
    ./Middel/emwin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf.c GUIDRV_Template_ST7789.c
  group Mid/emwin/Lib
    ./Middel/emwin/Lib/ARM/: GUI_CM3_L.lib GUI_CM4F_L.lib
  group Mid/emwin/OS
    ./Middel/emwin/OS/: GUI_X_FreeRTOS.c
  group Mid/emwin/Module
    ./Middel/emwin/GUI_NEW_Block/: EditModule.c Show_Image.c
  group Com
    ./Com/: Debug.c
software components: CMSIS:CORE 4.3.0
